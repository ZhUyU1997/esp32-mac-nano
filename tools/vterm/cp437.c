/* cp437.c — CP437 (IBM PC code page 437) byte -> Unicode conversion.
 *
 * Table generated from Python's cp437 codec (authoritative). The renderer
 * maps the resulting code points back to the VGA glyph indices via
 * term_unicode_to_cp437, so an art byte round-trips exactly.
 */
#include <stddef.h>
#include <stdint.h>

#include "cp437.h"

/* byte 0x80-0xFF -> Unicode (index 0 = byte 0x80) */
static const uint16_t k_cp437_hi[128] = {
	0x00C7, 0x00FC, 0x00E9, 0x00E2, 0x00E4, 0x00E0, 0x00E5, 0x00E7,
	0x00EA, 0x00EB, 0x00E8, 0x00EF, 0x00EE, 0x00EC, 0x00C4, 0x00C5,
	0x00C9, 0x00E6, 0x00C6, 0x00F4, 0x00F6, 0x00F2, 0x00FB, 0x00F9,
	0x00FF, 0x00D6, 0x00DC, 0x00A2, 0x00A3, 0x00A5, 0x20A7, 0x0192,
	0x00E1, 0x00ED, 0x00F3, 0x00FA, 0x00F1, 0x00D1, 0x00AA, 0x00BA,
	0x00BF, 0x2310, 0x00AC, 0x00BD, 0x00BC, 0x00A1, 0x00AB, 0x00BB,
	0x2591, 0x2592, 0x2593, 0x2502, 0x2524, 0x2561, 0x2562, 0x2556,
	0x2555, 0x2563, 0x2551, 0x2557, 0x255D, 0x255C, 0x255B, 0x2510,
	0x2514, 0x2534, 0x252C, 0x251C, 0x2500, 0x253C, 0x255E, 0x255F,
	0x255A, 0x2554, 0x2569, 0x2566, 0x2560, 0x2550, 0x256C, 0x2567,
	0x2568, 0x2564, 0x2565, 0x2559, 0x2558, 0x2552, 0x2553, 0x256B,
	0x256A, 0x2518, 0x250C, 0x2588, 0x2584, 0x258C, 0x2590, 0x2580,
	0x03B1, 0x00DF, 0x0393, 0x03C0, 0x03A3, 0x03C3, 0x00B5, 0x03C4,
	0x03A6, 0x0398, 0x03A9, 0x03B4, 0x221E, 0x03C6, 0x03B5, 0x2229,
	0x2261, 0x00B1, 0x2265, 0x2264, 0x2320, 0x2321, 0x00F7, 0x2248,
	0x00B0, 0x2219, 0x00B7, 0x221A, 0x207F, 0x00B2, 0x25A0, 0x00A0,
};

/* byte 0x01-0x1F -> Unicode: the VGA glyphs (smilies, card suits,
 * music notes, arrows…). Python's cp437 codec passes C0 through
 * unchanged, but ANSI art uses these bytes as glyphs — libansilove
 * renders them too (verified against its output). Tab, LF, CR and ESC
 * keep their control semantics. */
static const uint16_t k_cp437_lo[0x1F] = {
	/* 0x01-0x08 */
	0x263A, 0x263B, 0x2665, 0x2666, 0x2663, 0x2660, 0x2022, 0x25D8,
	0x0009, 0x000A, 0x25D9, 0x2642, 0x000D, 0x2640, 0x266A, 0x266B,
	0x263C, 0x25BA, 0x25C4, 0x2195, 0x203C, 0x00B6, 0x00A7, 0x25AC,
	0x2193, 0x2192, 0x001B, 0x221F, 0x2194, 0x25B2, 0x25BF,
};

uint32_t cp437_to_unicode(uint8_t b)
{
	if (b == 0x7f)
		return 0x25A0; /* VGA 0x7F is a solid square, not DEL */
	if (b == 0x00)
		return 0x20; /* VGA NULL glyph is blank: render as a space so the
		              * column advances (libansilove draws it blank and
		              * advances too); BBS art uses \x1b[D\x00 to erase */
	if (b >= 0x01 && b <= 0x1F)
		return k_cp437_lo[b - 0x01];
	return b < 0x80 ? b : k_cp437_hi[b - 0x80];
}

size_t cp437_to_utf8(const uint8_t *in, size_t n, char *out, size_t cap)
{
	size_t o = 0;
	for (size_t i = 0; i < n; i++) {
		uint32_t cp = cp437_to_unicode(in[i]);
		size_t need;
		if (cp < 0x80)
			need = 1;
		else if (cp < 0x800)
			need = 2; /* Latin-1 / Greek block */
		else
			need = 3; /* box drawing / blocks: U+2500+ need 3 bytes */
		if (out && o + need <= cap) {
			if (cp < 0x80) {
				out[o] = (char)cp;
			} else if (cp < 0x800) {
				out[o] = (char)(0xC0 | (cp >> 6));
				out[o + 1] = (char)(0x80 | (cp & 0x3F));
			} else {
				out[o] = (char)(0xE0 | (cp >> 12));
				out[o + 1] = (char)(0x80 | ((cp >> 6) & 0x3F));
				out[o + 2] = (char)(0x80 | (cp & 0x3F));
			}
		}
		o += need;
	}
	return o;
}
