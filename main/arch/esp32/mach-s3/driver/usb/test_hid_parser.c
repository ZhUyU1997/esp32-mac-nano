/*
 * HID Report Parser tests — all descriptors and report data from
 * github.com/o0Zz/HIDDataInterpreter/tests
 */
#include <stdio.h>
#include <string.h>
#include "hid_report_parser.h"

static int failures;
#define expect(c, ...) do { if (!(c)) { printf("FAIL: " __VA_ARGS__); failures++; } } while (0)

/* ---- Descriptors ---- */

static const uint8_t desc_mouse_complex[] = {
	0x05,0x01,0x09,0x02,0xA1,0x01,0x09,0x01,0xA1,0x00,
	0x05,0x09,0x19,0x01,0x29,0x05,0x15,0x00,0x25,0x01,
	0x75,0x01,0x95,0x05,0x81,0x02,0x75,0x01,0x95,0x03,
	0x81,0x03,0x06,0x00,0xFF,0x09,0x40,0x75,0x08,0x95,
	0x02,0x15,0x81,0x25,0x7F,0x81,0x02,0x05,0x01,0x09,
	0x38,0x15,0x81,0x25,0x7F,0x75,0x08,0x95,0x01,0x81,
	0x06,0x09,0x30,0x09,0x31,0x16,0x00,0x80,0x26,0xFF,
	0x7F,0x75,0x10,0x95,0x02,0x81,0x06,0xC0,0x06,0x00,
	0xFF,0x09,0x02,0x15,0x00,0x25,0x01,0x75,0x08,0x95,
	0x5A,0xB1,0x01,0xC0,
};

static const uint8_t desc_mouse_simple[] = {
	0x05,0x01,0x09,0x02,0xA1,0x01,0x09,0x01,0xA1,0x00,
	0x05,0x09,0x19,0x01,0x29,0x03,0x15,0x00,0x25,0x01,
	0x75,0x01,0x95,0x03,0x81,0x02,0x75,0x05,0x95,0x01,
	0x81,0x03,0x05,0x01,0x09,0x30,0x09,0x31,0x15,0x81,
	0x25,0x7F,0x75,0x08,0x95,0x02,0x81,0x06,0xC0,0xC0,
};

static const uint8_t desc_gamepad[] = {
	0x05,0x01,0x09,0x05,0xA1,0x01,0x85,0x01,0x09,0x30,
	0x09,0x31,0x15,0x00,0x26,0xFF,0x00,0x75,0x08,0x95,
	0x02,0x81,0x02,0x05,0x09,0x19,0x01,0x29,0x02,0x15,
	0x00,0x25,0x01,0x75,0x01,0x95,0x02,0x81,0x02,0x75,
	0x06,0x95,0x01,0x81,0x03,0xC0,
};

static const uint8_t desc_keyboard[] = {
	0x05,0x01,0x09,0x06,0xA1,0x01,0x05,0x07,0x19,0xE0,
	0x29,0xE7,0x15,0x00,0x25,0x01,0x75,0x01,0x95,0x08,
	0x81,0x02,0x95,0x01,0x75,0x08,0x81,0x03,0x95,0x06,
	0x75,0x08,0x15,0x00,0x25,0x65,0x05,0x07,0x19,0x00,
	0x29,0x65,0x81,0x00,0xC0,
};

/* Xbox360 gamepad (from test_joystick_xbox360.cpp) */
static const uint8_t desc_xbox360[] = {
	0x05,0x01,0x09,0x05,0xA1,0x01,0x05,0x01,0x09,0x3A,
	0xA1,0x02,0x75,0x08,0x95,0x02,0x05,0x01,0x09,0x3F,
	0x09,0x3B,0x81,0x01,0x75,0x01,0x15,0x00,0x25,0x01,
	0x95,0x04,0x05,0x09,0x19,0x0C,0x29,0x0F,0x81,0x02,
	0x75,0x01,0x15,0x00,0x25,0x01,0x95,0x04,0x05,0x09,
	0x09,0x09,0x09,0x0A,0x09,0x07,0x09,0x08,0x81,0x02,
	0x75,0x01,0x15,0x00,0x25,0x01,0x95,0x03,0x05,0x09,
	0x09,0x05,0x09,0x06,0x09,0x0B,0x81,0x02,0x75,0x01,
	0x95,0x01,0x81,0x01,0x75,0x01,0x15,0x00,0x25,0x01,
	0x95,0x04,0x05,0x09,0x19,0x01,0x29,0x04,0x81,0x02,
	0x75,0x08,0x15,0x00,0x26,0xFF,0x00,0x95,0x02,0x05,
	0x01,0x09,0x32,0x09,0x35,0x81,0x02,0x75,0x10,0x16,
	0x00,0x80,0x26,0xFF,0x7F,0x05,0x01,0x09,0x01,0xA1,
	0x00,0x95,0x02,0x05,0x01,0x09,0x30,0x09,0x31,0x81,
	0x02,0xC0,0x05,0x01,0x09,0x01,0xA1,0x00,0x95,0x02,
	0x05,0x01,0x09,0x33,0x09,0x34,0x81,0x02,0xC0,0xC0,
	0xC0,
};

/* PS4 gamepad (from test_joystick_ps4.cpp, truncated features) */
static const uint8_t desc_ps4[] = {
	0x05,0x01,0x09,0x05,0xA1,0x01,0x85,0x01,0x09,0x30,
	0x09,0x31,0x09,0x32,0x09,0x35,0x15,0x00,0x26,0xFF,
	0x00,0x75,0x08,0x95,0x04,0x81,0x02,0x09,0x39,0x15,
	0x00,0x25,0x07,0x75,0x04,0x95,0x01,0x81,0x42,0x05,
	0x09,0x19,0x01,0x29,0x0E,0x15,0x00,0x25,0x01,0x75,
	0x01,0x95,0x0E,0x81,0x02,0x06,0x00,0xFF,0x09,0x20,
	0x75,0x06,0x95,0x01,0x15,0x00,0x25,0x7F,0x81,0x02,
	0x05,0x01,0x09,0x33,0x09,0x34,0x15,0x00,0x26,0xFF,
	0x00,0x75,0x08,0x95,0x02,0x81,0x02,0x06,0x00,0xFF,
	0x09,0x21,0x95,0x36,0x81,0x02,0xC0,
};

/* ---- Tests ---- */

static void test_read_bits(void)
{
	printf("--- read_bits ---\n");
	struct hid_field f = {.report_count = 1, .logical_minimum = 0};
	uint8_t buf[] = {0x01, 0x03};

	f.report_size = 9; expect(hid_field_extract(&f, buf, 2, 0) == 0x101, "off=0 sz=9 want 0x101\n");
	f.report_size = 8; expect(hid_field_extract(&f, buf, 2, 0) == 0x01,  "off=0 sz=8 want 0x01\n");
	f.report_offset = 1; f.report_size = 7;
	expect(hid_field_extract(&f, buf, 2, 0) == 0, "off=1 sz=7 want 0\n");
	f.report_offset = 0; f.report_size = 16;
	expect(hid_field_extract(&f, buf, 2, 0) == 0x301, "off=0 sz=16 want 0x301\n");
	f.report_offset = 1; f.report_size = 8;
	expect(hid_field_extract(&f, buf, 2, 0) == 0x80,  "off=1 sz=8 want 0x80\n");
	uint8_t buf2[] = {0x54, 0x01};
	f.report_offset = 0; f.report_size = 10;
	expect(hid_field_extract(&f, buf2, 2, 0) == 0x154, "off=0 sz=10 want 0x154\n");
}

static void test_mouse_buttons(void)
{
	printf("--- mouse: buttons ---\n");
	struct hid_device *h = hid_parse_device(desc_mouse_complex, sizeof(desc_mouse_complex));
	if (!h) { printf("FAIL: parse\n"); failures++; return; }
	uint8_t d[] = {0x05,0,0,0,0,0,0,0};
	struct hid_field *f;
	f = hid_find_field(h, HID_REPORT_TYPE_INPUT, 0x09, 1); expect(f && hid_field_extract(f,d,8,0)==1, "btn1\n");
	f = hid_find_field(h, HID_REPORT_TYPE_INPUT, 0x09, 2); expect(f && hid_field_extract(f,d,8,0)==0, "btn2\n");
	f = hid_find_field(h, HID_REPORT_TYPE_INPUT, 0x09, 3); expect(f && hid_field_extract(f,d,8,0)==1, "btn3\n");
	hid_destroy_device(h);
}

static void test_mouse_movement(void)
{
	printf("--- mouse: 16-bit XY + wheel ---\n");
	struct hid_device *h = hid_parse_device(desc_mouse_complex, sizeof(desc_mouse_complex));
	if (!h) { printf("FAIL: parse\n"); failures++; return; }
	uint8_t d[] = {0,0,0,1,0x64,0,0xCE,0xFF};
	struct hid_field *fx = hid_find_field(h, HID_REPORT_TYPE_INPUT, 0x01, 0x30);
	struct hid_field *fy = hid_find_field(h, HID_REPORT_TYPE_INPUT, 0x01, 0x31);
	struct hid_field *fw = hid_find_field(h, HID_REPORT_TYPE_INPUT, 0x01, 0x38);
	expect(fx && hid_field_extract(fx,d,8,0)==100, "X\n");
	expect(fy && hid_field_extract(fy,d,8,0)==-50, "Y\n");
	expect(fw && hid_field_extract(fw,d,8,0)==1,   "wheel\n");
	hid_destroy_device(h);
}

static void test_keyboard_modifiers(void)
{
	printf("--- keyboard: modifiers ---\n");
	struct hid_device *h = hid_parse_device(desc_keyboard, sizeof(desc_keyboard));
	if (!h) { printf("FAIL: parse\n"); failures++; return; }
	/* LeftCtrl(bit0)+LeftShift(bit1)=0x03 */
	uint8_t d[] = {0x03,0,0,0,0,0,0,0};
	struct hid_field *f;
	f = hid_find_field(h, HID_REPORT_TYPE_INPUT, 0x07, 0xe0);
	expect(f && hid_field_extract(f,d,8,0)==1, "LCtrl\n");
	f = hid_find_field(h, HID_REPORT_TYPE_INPUT, 0x07, 0xe1);
	expect(f && hid_field_extract(f,d,8,0)==1, "LShift\n");
	f = hid_find_field(h, HID_REPORT_TYPE_INPUT, 0x07, 0xe2);
	expect(f && hid_field_extract(f,d,8,0)==0, "LAlt\n");
	hid_destroy_device(h);
}

static void test_keyboard_keys(void)
{
	printf("--- keyboard: keys ---\n");
	struct hid_device *h = hid_parse_device(desc_keyboard, sizeof(desc_keyboard));
	if (!h) { printf("FAIL: parse\n"); failures++; return; }
	/* Keyboard has 8 modifier fields + 1 const + 6 key array = 15 input fields.
	 * Verify parsing succeeds and field count is reasonable. */
	unsigned n = 0;
	for (unsigned i = 0; i < HID_MAX_IDS; i++) {
		struct hid_report *r = h->report_enum[0]
			? h->report_enum[0]->report_id_hash[i] : NULL;
		if (r) n += r->maxfield;
	}
	expect(n >= 14, "kbd fields %u < 14\n", n);
	hid_destroy_device(h);
}

static void test_xbox360_button(void)
{
	printf("--- xbox360: button ---\n");
	struct hid_device *h = hid_parse_device(desc_xbox360, sizeof(desc_xbox360));
	if (!h) { printf("FAIL: parse\n"); failures++; return; }
	uint8_t d[] = {0x00,0x14,0x00,0x10,0x00,0x00,0xcd,0x01,0x36,0xfd,
	               0x2c,0x03,0xe9,0xfb,0,0,0,0,0,0};
	struct hid_field *f = hid_find_field(h, HID_REPORT_TYPE_INPUT, 0x09, 1);
	expect(f && hid_field_extract(f,d,20,0)==1, "btn1\n");
	hid_destroy_device(h);
}

static void test_ps4_button(void)
{
	printf("--- ps4: button1 ---\n");
	struct hid_device *h = hid_parse_device(desc_ps4, sizeof(desc_ps4));
	if (!h) { printf("FAIL: parse\n"); failures++; return; }
	/* Skip Report ID byte (0x01), data starts at offset 1 */
	uint8_t d[] = {0x83,0x79,0x84,0x80,0x18,0x00,0x50,0};
	struct hid_field *f = hid_find_field(h, HID_REPORT_TYPE_INPUT, 0x09, 1);
	expect(f && hid_field_extract(f,d,8,0)==1, "btn1\n");
	hid_destroy_device(h);
}

static void test_ps4_hatswitch(void)
{
	printf("--- ps4: hatswitch ---\n");
	struct hid_device *h = hid_parse_device(desc_ps4, sizeof(desc_ps4));
	if (!h) { printf("FAIL: parse\n"); failures++; return; }
	/* Skip Report ID byte */
	uint8_t d[] = {0x82,0x7a,0x82,0x80,0x00,0};
	struct hid_field *f = hid_find_field(h, HID_REPORT_TYPE_INPUT, 0x01, 0x39);
	expect(f != NULL, "hatswitch field\n");
	if (f) expect(hid_field_extract(f, d, 6, 0) == 0, "hat UP\n");
	hid_destroy_device(h);
}

static void test_descriptors(void)
{
	printf("--- descriptors ---\n");
#define CHECK(p,pg,id) do { \
	struct hid_device *h = hid_parse_device(p, sizeof(p)); \
	expect(h != NULL, "parse %s\n", #p); \
	if (h) { expect(hid_find_field(h,HID_REPORT_TYPE_INPUT,pg,id)!=NULL, "%s field 0x%04x\n",#p,id); hid_destroy_device(h); } \
} while (0)

	CHECK(desc_mouse_simple, 0x01, 0x30);
	CHECK(desc_gamepad, 0x01, 0x30);
	CHECK(desc_keyboard, 0x07, 0xe0);
	CHECK(desc_xbox360, 0x01, 0x30);
	CHECK(desc_ps4, 0x01, 0x30);
}

int test_hid_parser(void)
{
	printf("=== HID Report Parser Tests ===\n");
	failures = 0;

	test_read_bits();
	test_mouse_buttons();
	test_mouse_movement();
	test_keyboard_modifiers();
	test_keyboard_keys();
	test_xbox360_button();
	test_ps4_button();
	test_ps4_hatswitch();
	test_descriptors();

	printf("%s: %d failures\n", failures ? "FAIL" : "PASS", failures);
	return failures;
}

int main(void) { return test_hid_parser(); }
